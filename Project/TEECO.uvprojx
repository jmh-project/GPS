# Keil uVision project TEECO.uvprojx, settings and files
target TEECO_Standard (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TEECO
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM324xG_EVAL, USE_STDPERIPH_DRIVER,USE_USB_OTG_FS, STM32F4XX, MEDIA_USB_KEY,__LITTLE_ENDIAN__,__CPLUSPLUS,STM32F427_437xx,STM32F4XX,USE_STDPERIPH_DRIVER
  c include: ..\STARTUP;..\STARTUP\Include;..\Entry;..\GUI\Graphics;..\GUI\Windows;..\Includes;..\Utility\DEBUG;..\BSP\Touch_ADS7843;..\BSP\Nand;..\BSP\EEPROM;..\BSP\GPU_SM718;..\BSP;..\BSP\USB;..\USB\STM32_USB_HOST_Library\Core;..\FAT_FS\src;..\FAT_FS\inc;..\USB\STM32_USB_HOST_Library\Core\inc;..\USB\STM32_USB_HOST_Library\Core\src;..\USB\STM32_USB_HOST_Library\Class\MSC\src;..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\USB\STM32_USB_OTG_Driver\inc;..\USB\STM32_USB_OTG_Driver\src;..\BSP\IIC;..\Resource_Manager;..\Utility\String;..\BSP\BSP_RTC;..\Application\Widget_Test;..\BSP\DS1302;..\BSP\CAN;..\BSP\KeyPad;..\USB\USB_Device_Src;..\USB\STM32_USB_Device_Library\Class\msc\src;..\USB\STM32_USB_Device_Library\Class\msc\inc;..\USB\STM32_USB_Device_Library\Core\src;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_HOST_Library\Class\HID\src;..\USB\STM32_USB_HOST_Library\Class\HID\inc;..\USB\USB_HID_Src;..\BSP\Wifi250;..\Utility\LinkedList;..\LAN_W5500;..\USB\USB_Process;..\Application\SCADA;..\FAT_FS\src\option;..\GUI\LowFont;..\GUI\IOProcess;..\FreeRTOS;..\FreeRTOS\Source;..\FreeRTOS\Source\CMSIS_RTOS;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\FreeRTOS\Source\portable\MemMang;..\Application\UPS_Monitor;..\Application\WaterCell;..\C++Windows;..\Utility\Ref;..\Application\7Inch_DataLog;..\EmWin;..\EmWin\inc;..\EmWin\Lib;..\Application\Radium;..\STM32F4xx_DSP_StdPeriph_Lib_V1.5.1\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4xx_DSP_StdPeriph_Lib_V1.5.1\Utilities\STM32_EVAL\TEECO;..\STM32F4xx_DSP_StdPeriph_Lib_V1.5.1\Libraries\STM32F4xx_StdPeriph_Driver\src;C:\Keil_v5\ARM\ARMCC\include
  asm misc: --cpreproc
  asm include: ..\Includes
  memory RVCT4: ROM 0x8020000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --entry Reset_Handler
  group STARTUP
    ../STARTUP/: system_stm32f4xx_Codec.c startup_stm32f427x.s
  group Entry
    ../Entry/: stm32f4xx_it.c Teecomain.c
    ../Includes/: TEECO_HW_Config.h TEECO_System.h
  group BSP
    ../BSP/IIC/: BSP_Port_I2C.c
    ../BSP/Touch_ADS7843/: BSP_ADS7843.c
    ../BSP/Nand/: BSP_Nand.c
    ../BSP/EEPROM/: BSP_EEProm.c
    ../BSP/: BSP_Init.c BSP_Uart.c BSP_ADV7611.c Voice.c SiI9293.c SiI9293_Rx.c EDID_Write.c stm324xg_eval_sdio_sd.c
    ../BSP/USB/: usb_bsp.c usbh_usr.c
    ../BSP/GPU_SM718/: BSP_SM718.c BSP_SAA7113H.c
    ../BSP/BSP_RTC/: Test_RTC.c
    ../BSP/DS1302/: BSP_DS1302.c
    ../BSP/CAN/: BSP_Can.c BSP_Can.h
    ../BSP/Wifi250/: BSP_W250.c
    ../STM32F4xx_DSP_StdPeriph_Lib_V1.5.1/Utilities/STM32_EVAL/TEECO/: stm324xg_eval.c
  group Resource_Manager
    ../Resource_Manager/: MemoryManager.c NandFileSystem.c
  group GUI-Windows
    ../GUI/Windows/: Windows.c Windows.h Message.c WinTimer.c Windows_Sample.c
    ../GUI/Graphics/: IconOut.c
    ../GUI/IOProcess/: IOProcess.c IOProcess.h
  group GUI-Graphics
    ../GUI/Graphics/: WindowsGraphics.c LowGraphics.c WinStyleDraw.c Fontout.c UniCodeTable.c WindowsGraphics.h AliasingFont.c
    ../GUI/LowFont/: LowFont.c Abadi10.c Abadi12.c ARIAL12.c ARIAL18.c ARIAL18B.c HanFont.c IBM15.c LCD57.c MS_Serief9.c ROMA29.c TIME18.c timeroma9.c TimeRoma9b.c TimeRoma12.c TimeRoma12b.c TimeRoma16.c TimeRoma16B.c
  group GUI-Widget
    ../GUI/Window-Widget/: Memory_Button.c FileButton.c Button.c TextBox.c WidgetCommon.c RadioButton.c CheckBox.c LineBar.c ProgresssBar.c ImageBox.c ScrollBar.c Panel.c GroupBox.c IconBox.c TransParencyTextBox.c GraphBox.c MemoWidget.c RButton.c WidgetSample.c TransParency_MultiLineTextBox.c SystemButton.c RoundButton.c RoundRectButton.c ButtonControl.c ComboWidget.c SystemTextBox.c SystemPanel.c PowerButton.c
  group GUI-DialogBox
    ../GUI/DialogBox/: KeyPad.c KeyBoard.c KeyPadTime.c
  group FAT_FS
    ../FAT_FS/src/: fattime.c ff.c diskio.c Examples.c FS_Examples.c dos.c
    ../FAT_FS/src/option/: cc949.c syscall.c
    ../FAT_FS/inc/: ffconf.h
  group Utility
    ../Utility/DEBUG/: Debug_Uart.c Debug_Uart.h
    ../Utility/String/: String.c UTF8ToKr.c xprintf.c xprintf.h StringClass.c StringClass.h String.h
  group USB_HOST
    ../USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
    ../USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
    ../USB/USB_Process/: USB_Process.c
  group W5500
    ../LAN_W5500/: W5500_main.c T_dhcp.c BSP_W5500.c T_Socket.c W5500.c wizchip_conf.c dns.c T_loopback.c
  group FreeRTOS
    ../FreeRTOS/: freertos.c FreeRTOSConfig.h
    ../FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/include/: FreeRTOS.h
  group MyWidget
    ../GUI/MyWidget/: TitleBar.c SButton.c STransTextBox.c Label.c STextBox.c SLabel.c SKeyPad.c SWin_Draw.c SCheckBox.c GroupPanel.c TextPanel.c SIcon.c BIcon.c SConfirm_Window.c Info_Window.c ButtonSystemPanel.c SaveWindow.c Ruller.c DateInput_Window.c
  group C++Windows
    ../C++Windows/: ObjectWindow.cpp
  group Reference
    ../Utility/Ref/: Enum_Example.c
  group std_FWLib1.5.1New Group
    ../STM32F4xx_DSP_StdPeriph_Lib_V1.5.1/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DataLog
    ../Application/7Inch_DataLog/: DataLog.h DataLogExtern.h SystemInitialization.c DataLogDefine.h DataLog_Init.c DataLog_Interrupt.c DataLog_Main.c DataLog_Rename_Window.c DataLog_USB.c DataLog_420ItemSelect.c
  group WINDOW
    ../Application/7Inch_DataLog/: DataLog_ScreenCreate.c DataLog_UartWindow_Common.c DataLog_ADInput_EightWindow.c DataLog_ADInput_FourWindow.c DataLog_ADInput_SixWindow.c DataLog_ADInput_TwoWindow.c DataLog_Uart5_8Window.c DataLog_Uart5_6Window.c DataLog_Uart5_4Window.c DataLog_Uart5_2Window.c DataLog_Uart4_8Window.c DataLog_Uart4_6Window.c DataLog_Uart4_4Window.c DataLog_Uart4_2Window.c DataLog_Uart3_8Window.c DataLog_Uart3_6Window.c DataLog_Uart3_4Window.c DataLog_Uart3_2Window.c DataLog_Uart2_8Window.c DataLog_Uart2_6Window.c DataLog_Uart2_4Window.c DataLog_Uart2_2Window.c DataLog_Uart1_10Window.c DataLog_Uart1_8Window.c DataLog_Uart1_6Window.c DataLog_Uart1_4Window.c DataLog_Uart1_2Window.c DataLog_Uart1_12Window.c
  group SETUP
    ../Application/7Inch_DataLog/: DataLog_UartSelectItemInfo.c DataLog_UsartItem.c DataLog_Sensor.c DataLog_System.c DataLog_UsartRate.c DataLog_ValuePoint.c
  group YSI
    ../Application/7Inch_DataLog/: DataLog_YSI_Process.c DataLog_YSI_Para.c DataLog_YSI_ErrorCheck_Process.c DataLog_YSI_Config.c
  group KIMWIDGET
    ../Application/7Inch_DataLog/: DataLog_SKeyPad.c DataLog_Message_Box.c DataLog_Calender.c DataLog_InfoWindow.c NButton.c NGroupPanel.c NInfo_Window.c NLabel.c NTitleBar.c DataLog_SystemPanel.c DataLog_ToolBox.c DataLog_TowLineText_Label.c DataLog_Password.c
  group IOPROCESS
    ../Application/7Inch_DataLog/: DataLog_W5500_Ioprocess.c DataLog_USB_IOprocess.c DataLog_Hardware_IOProcess.c DataToSDCard.c DataLog_Option.c
  group EXO
    ../Application/7Inch_DataLog/: DataLog_EXO_IOProcess.c DataLog_EXO_ItemSelect.c DataLog_EXO_Screen.c DataLog_EXO_DispItem.c
  group IOProcessFuction
    ../Application/7Inch_DataLog/: DataLog_Uart1_Process.c DataLog_Uart5_Process.c DataLog_Uart4_Process.c DataLog_Uart3_Process.c DataLog_Uart2_Process.c DataLog_Message.c AD420mAOutProcess.c
  group RTU_Component
    ../Application/7Inch_DataLog/: DataLog_TitleBar.c
  group TCPIP
    ../Application/7Inch_DataLog/: TcpSampleSave.c json.c
  group TMS
    ../Application/7Inch_DataLog/: KECO_Protocol.c TypeApprovalProtocol.c TypeApprovalNameChange.c TypeApprovalFactorView.c
  group ULIK
    ../Application/7Inch_DataLog/: UlikSensor.c UlickSensorCalScreen.c UlikMessageBox.c
  group ULIK_MW
    ../Application/7Inch_DataLog/: Ulik_MWSensor.c Ulik_MWCalScreen.c
  group ModBus
    ../Application/7Inch_DataLog/: ModBus.c
  group YSI_ODO
    ../Application/7Inch_DataLog/: odo.c odoCalScreen.c ctCalScreen.c odo_CapCoefficient.c
  group CTD
    ../Application/7Inch_DataLog/: CTD_Sensor.c CTD_CalScreen.c CTD_DepthSensor.c
  group BATTERY
    ../Application/7Inch_DataLog/: Tracer.c
  group PONSEL
    ../Application/7Inch_DataLog/: ponsec_ec.c
  group DEBUG
    ../Application/7Inch_DataLog/: DebugScreen.c
  group GPS
    ./: QUESCAN_GPS.c
target TEECO_Smartx (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: TEECO
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM324xG_EVAL, STM32F4XX,USE_STDPERIPH_DRIVER, STM32F4XX, MACH_GEN,__LITTLE_ENDIAN__
  c include: ..\STARTUP;..\STARTUP\Include;..\Entry;..\FAT32;..\GUI\Event;..\GUI\Font;..\GUI\Graphics;..\GUI\Image;..\GUI\InputDevice;..\GUI\Layer_DoubleBuffering;..\GUI\Timer;..\GUI\Widget\Button;..\GUI\Windows;..\Includes;..\STM32F4_DSP_StdPeriph_Lib_V1.0.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4_DSP_StdPeriph_Lib_V1.0.0\Libraries\STM32F4xx_StdPeriph_Driver\src;..\STM32F4_DSP_StdPeriph_Lib_V1.0.0\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\uC-OS-II\CPU;..\uC-OS-II\Lib;..\uC-OS-II\Port;..\uC-OS-II\Source;..\Utility\Memory;..\STM32F4_DSP_StdPeriph_Lib_V1.0.0\Utilities\STM32_EVAL\Common;..\Utility\DEBUG;..\GUI\Widget;..\BSP\Touch_ADS7843;..\BSP\Nand;..\BSP\Sound-DAC;..\BSP\EEPROM;..\BSP\GPU_SM718;..\BSP\Audio;..\BSP;..\BSP\USB;..\FAT32;..\USB\STM32_USB_HOST_Library\Core;..\FAT_FS\src;..\FAT_FS\inc;..\USB\STM32_USB_HOST_Library\Core\inc;..\USB\STM32_USB_HOST_Library\Core\src;..\USB\STM32_USB_HOST_Library\Class\MSC\src;..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\USB\STM32_USB_OTG_Driver\inc;..\USB\STM32_USB_OTG_Driver\src;..\BSP\IIC;..\GUI\LowLevelGraphics;..\Resource_Manager;..\Utility\String;..\Audio;..\BSP\BSP_RTC;..\Application\SmartX_O2Run;..\IOProcess;..\Tools;..\BSP\ST16C554;..\LAN\iinchip;..\LAN\mcu;..\LAN\evb;..\LAN\app;..\LAN\util;..\UBI9033\TestCode;..\UBI9033\include;..\UBI9033\include\Arch;..\UBI9033\include\Arch\mach-GEN;..\UBI9033\include\BasicFileSystem;..\UBI9033\include\MassStorageClass;..\UBI9033\include\Ubi9033;..\UBI9033\src;..\UBI9033\src\Example\Common;..\UBI9033\src\BasicFileSystem;..\UBI9033\src\MassStorageClass;..\UBI9033\src\Ubi9033;..\Application\SmartLog;..\Application\Label;..\Application\Widget_Test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --entry Reset_Handler
